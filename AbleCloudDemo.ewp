# IAR project AbleCloudDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1; RT_DEBUG_SUPPORT; xI2C_DEVICE_SUPPORT; WIFI_DEVICE_SUPPORT; xZIGBEE_DEVICE_SUPPORT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: include; src\ac; driverlib; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: AbleCloudDemo.bin
  ILINK.IlinkOutputFile: AbleCloudDemo.out
  ILINK.IlinkIcfFile: AbleCloudDemo.icf
  ILINK.IlinkAdditionalLibs: driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Inc
    src/ac/: ac_api.h ac_cfg.h ac_common.h ac_hal.h ac_protocol_interface.h
    include/: bmd.h Iot_Key.h Iot_Timer.h Iot_Uart.h
  group Source
    src/ac/: ac_api.c ac_common.c ac_hal.c crc.c
    src/: Iot_Key.c Iot_Timer.c main.c startup_ewarm.c uartstdio.c
    src/uart/: Iot_Uart.c
